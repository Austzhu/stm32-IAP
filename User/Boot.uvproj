# Keil uVision project Boot.uvproj, settings and files
target Boot (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Boot +hex
  AfterMake: fromelf.exe --bin -o ..\Boot.bin  ..\Output\Boot.axf
  c flags: uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Lib\inc;..\User;..\Lib\src;..\CMSIS;..\Hardware;..\Hardware\Delay;..\Hardware\Uart;..\Software\Init;..\Software\Format;..\Debug;..\Hardware\LED;..\Hardware\Address;..\Software\Crc16;..\Software\TIM;..\Hardware\AT24CXX;..\Software\Update;..\Hardware\PWM;..\Hardware\WDG;..\Hardware\ADC;..\Hardware\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c stm32f10x_it.c Interface.c Config.h Include.h
  group lib
    ../Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group startup
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group cmsis
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group hardware
    ../Hardware/Uart/: Uart.c
    ../Hardware/Delay/: delay.c
    ../Hardware/LED/: led.c
    ../Hardware/AT24CXX/: AT24CXX.c
    ../Hardware/WDG/: wdg.c
    ../Hardware/TIMER/: timer.c
  group software
    ../Software/Init/: Init.c
    ../Software/Format/: Format_Data.c
    ../Software/Crc16/: Crc16.c
    ../Software/TIM/: TIM.c
    ../Software/Update/: update.c update.h FlashProgram.c
  group debug
    ../Debug/: debug.h
